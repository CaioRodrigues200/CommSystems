options:
  parameters:
    author: Caio
    generate_options: hb
    id: QAMModulator_CAIO
    output_language: python
    title: QAM Mod Caio
  states: {}

blocks:
- name: BPSK
  id: variable_constellation
  parameters:
    const_points: '[-1,1]'
    npwr: '0'
    precision: '8'
    sym_map: '[-1,1]'
    type: bpsk
  states: {}
- name: CarrierFreq
  id: parameter
  parameters:
    label: Carrier Frequency
    value: '2000'
  states: {}
- name: RRC_Ratio
  id: parameter
  parameters:
    label: RRC Filter Ratio
    value: '64'
  states: {}
- name: SPSymb
  id: parameter
  parameters:
    label: Samples per Symbol
    value: '64'
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: CarrierFreq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: CarrierFreq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: BPSK
    differential: 'True'
    excess_bw: '0.8'
    samples_per_symbol: SPSymb
  states: {}
- name: digital_constellation_modulator_0_1
  id: digital_constellation_modulator
  parameters:
    constellation: BPSK
    differential: 'True'
    excess_bw: '0.8'
    samples_per_symbol: SPSymb
  states: {}
- name: filter_fft_rrc_filter_0_0_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '1'
    decim: '1'
    gain: '1'
    ntaps: '1024'
    samp_rate: samp_rate
    sym_rate: RRC_Ratio*samp_rate//SPSymb
    type: fff
  states: {}
- name: filter_fft_rrc_filter_0_0_0_1
  id: filter_fft_rrc_filter
  parameters:
    alpha: '1'
    decim: '1'
    gain: '1'
    ntaps: '1024'
    samp_rate: samp_rate
    sym_rate: RRC_Ratio*samp_rate//SPSymb
    type: fff
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: Base_I
    type: float
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: Base_Q
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in1
    type: byte
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in2
    type: byte
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    value: '32000'
  states: {}

connections:
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_1, '1']
- [analog_sig_source_x_0_2, '0', blocks_multiply_xx_0_1_0, '1']
- [blocks_add_xx_0_0, '0', pad_sink_0, '0']
- [blocks_complex_to_float_0, '0', filter_fft_rrc_filter_0_0_0, '0']
- [blocks_complex_to_float_0_0, '0', filter_fft_rrc_filter_0_0_0_1, '0']
- [blocks_multiply_xx_0_1, '0', blocks_add_xx_0_0, '0']
- [blocks_multiply_xx_0_1_0, '0', blocks_add_xx_0_0, '1']
- [blocks_throttle2_0_0, '0', blocks_complex_to_float_0, '0']
- [blocks_throttle2_0_1, '0', blocks_complex_to_float_0_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle2_0_0, '0']
- [digital_constellation_modulator_0_1, '0', blocks_throttle2_0_1, '0']
- [filter_fft_rrc_filter_0_0_0, '0', blocks_multiply_xx_0_1, '0']
- [filter_fft_rrc_filter_0_0_0, '0', pad_sink_0_0, '0']
- [filter_fft_rrc_filter_0_0_0_1, '0', blocks_multiply_xx_0_1_0, '0']
- [filter_fft_rrc_filter_0_0_0_1, '0', pad_sink_0_0_0, '0']
- [pad_source_0, '0', digital_constellation_modulator_0_0, '0']
- [pad_source_0_0, '0', digital_constellation_modulator_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
