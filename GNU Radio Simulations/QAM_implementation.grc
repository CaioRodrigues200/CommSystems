options:
  parameters:
    generate_options: qt_gui
    id: QAM_Caio
    output_language: python
    title: QAM Implementation
  states: {}

blocks:
- name: AdaptiveEqualizer
  id: variable_adaptive_algorithm
  parameters:
    cons: ConstObj
    modulus: '8'
    step_size: '0.0001'
    type: lms
  states: {}
- name: ConstObj
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: LP_Ratio
  id: variable_qtgui_range
  parameters:
    gui_hint: 12,0,1,4
    label: Fator de banda LP receptor
    min_len: '100'
    start: '0.6'
    step: '0.2'
    stop: '8'
    value: '1'
  states: {}
- name: Noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,4
    label: Noise
    min_len: '100'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0'
    widget: eng_slider
  states: {}
- name: QPSK_Dec
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: RRC_Ratio
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,4
    label: Fator de banda RRC
    min_len: '100'
    start: '0.02'
    step: '0.02'
    stop: '1'
    value: '1'
  states: {}
- name: SPSymb
  id: variable
  parameters:
    value: '16'
  states: {}
- name: numTaps
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: QAMModulator_CAIO_0
  id: QAMModulator_CAIO
  parameters:
    CarrierFreq: 4*samp_rate//SPSymb
    RRC_Ratio: RRC_Ratio
    SPSymb: SPSymb
    samp_rate: samp_rate
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: Noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 4*samp_rate//SPSymb
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 4*samp_rate//SPSymb
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '0.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: SPSymb
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: cc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '1'
    cutoff_freq: LP_Ratio*samp_rate//SPSymb
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    beta: '1'
    cutoff_freq: LP_Ratio*samp_rate//SPSymb
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: int(SPSymb*SPSymb)
    type: complex
    update_time: '0.2'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,2,4
    label1: post
    name: '"Post RRC"'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 6,2,2,2
    label1: Real
    name: '"Channel"'
    type: float
    width1: '2'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 15,0,2,4
    label1: Real
    label2: Imag
    name: '"Received signal"'
    nconnections: '2'
    type: float
    width1: '2'
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 10,0,2,2
    label1: Real
    name: '"Multiplication I"'
    type: float
    width1: '2'
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 10,2,2,2
    label1: Real
    name: '"Multiplication Q"'
    type: float
    width1: '2'
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 0,0,2,4
    label1: Real
    label2: Imag
    name: '"Transmission"'
    size: SPSymb*SPSymb*8
    srate: samp_rate
    type: complex
    update_time: '0.4'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 6,0,2,2
    label1: Real
    name: '"Channel"'
    size: int(SPSymb*SPSymb*8)
    srate: samp_rate
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 13,0,2,4
    label1: Real
    label2: Imag
    name: '"Received signal"'
    nconnections: '2'
    size: int(SPSymb*SPSymb*8)
    srate: samp_rate
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    label1: Real
    label2: Imag
    marker1: '0'
    marker2: '1'
    name: '"Post sync Signal"'
    size: int(SPSymb*SPSymb*1)
    srate: samp_rate
    type: complex
    update_time: '0.4'
  states: {}

connections:
- [QAMModulator_CAIO_0, '0', blocks_add_xx_0, '0']
- [QAMModulator_CAIO_0, '1', blocks_float_to_complex_0, '0']
- [QAMModulator_CAIO_0, '2', blocks_float_to_complex_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', QAMModulator_CAIO_0, '0']
- [analog_random_source_x_0_0, '0', QAMModulator_CAIO_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_complex_1, '0', digital_symbol_sync_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_freq_sink_x_0_0_0_1, '0']
- [blocks_multiply_xx_0_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', qtgui_freq_sink_x_0_0_0_1_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [low_pass_filter_0, '0', blocks_float_to_complex_1, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_float_to_complex_1, '1']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0_0, '1']
- [low_pass_filter_0_0, '0', qtgui_time_sink_x_0_0_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
